options:
  parameters:
    generate_options: qt_gui
    id: LoRaWAN
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '250000'
    center_freq: '915000000'
    impl_head: 'False'
    os_factor: '2'
    preamb_len: '8'
    sf: '7'
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: '250000'
    center_freq0: 915e6
    dev_addr: '"source=30F4146"'
    rx_agc0: Enabled
    samp_rate: '500000'
    sync: sync
    type: fc32
  states: {}

connections:
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', lora_sdr_frame_sync_0, '0']
- [uhd_usrp_source_0, async_msgs, lora_sdr_frame_sync_0, frame_info]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
