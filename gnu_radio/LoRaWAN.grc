options:
  parameters:
    author: žan
    generate_options: qt_gui
    id: LoRaWAN
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("hello")
    period: '2000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: 'True'
  states: {}
- name: lora_sdr_gray_demap_1
  id: lora_sdr_gray_demap
  parameters:
    sf: '7'
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: '1'
    sf: '7'
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: '1'
    ldro: '0'
    sf: '7'
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: '125000'
    frame_zero_padd: int(20*2**7*250000/500000)
    preamb_len: '8'
    samp_rate: '250000'
    sf: '7'
    sync_words: '18'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: '125000'
    center_freq0: 915e6
    dev_addr: '"serial=30F4194"'
    gain0: '5'
    samp_rate: '250000'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_message_strobe_0, strobe, lora_sdr_whitening_0, msg]
- [blocks_null_source_0, '0', blocks_add_xx_0, '1']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_demap_1, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_1, '0']
- [lora_sdr_modulate_0, '0', blocks_add_xx_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
